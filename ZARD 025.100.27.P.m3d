# KOMPAS-3D part (ZARD 025.100.27.P.m3d)

Model tree:
1. Плоскость XY
2. Плоскость ZX
3. Плоскость ZY
4. Ось X
5. Ось Y
6. Ось Z
7. Начало координат
8. Булева операция:3
9. Булева операция:4
10. Булева операция:5
11. Булева операция:6
